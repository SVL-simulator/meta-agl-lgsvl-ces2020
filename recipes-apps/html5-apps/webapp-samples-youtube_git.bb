# Copyright (c) 2019 LG Electronics, Inc.

SUMMARY = "Web app sample - youtube"

require webapp-samples.inc

SAMPLE_PATH = "youtube"
