# Copyright (c) 2019 LG Electronics, Inc.

SUMMARY = "Web app sample - solar system"

require webapp-samples.inc

SAMPLE_PATH = "solar-system"
