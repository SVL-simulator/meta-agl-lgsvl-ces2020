# Copyright (c) 2019 LG Electronics, Inc.

SUMMARY = "Web app sample - aquarium"

require webapp-samples.inc

SAMPLE_PATH = "aquarium"
