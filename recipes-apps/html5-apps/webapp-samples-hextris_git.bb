# Copyright (c) 2019 LG Electronics, Inc.

SUMMARY = "Web app sample - hextris"

require webapp-samples.inc

SAMPLE_PATH = "hextris"
