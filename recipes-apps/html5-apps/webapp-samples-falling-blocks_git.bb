# Copyright (c) 2019 LG Electronics, Inc.

SUMMARY = "Web app sample - falling blocks"

require webapp-samples.inc

SAMPLE_PATH = "falling-blocks"
