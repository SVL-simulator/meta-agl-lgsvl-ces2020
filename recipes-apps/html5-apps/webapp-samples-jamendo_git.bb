# Copyright (c) 2019 LG Electronics, Inc.

SUMMARY = "Web app sample - jamendo"

require webapp-samples.inc

SAMPLE_PATH = "jamendo"
