# Copyright (c) 2019 LG Electronics, Inc.

SUMMARY = "Web app sample - memory match"

require webapp-samples.inc

SAMPLE_PATH = "memory-match"
