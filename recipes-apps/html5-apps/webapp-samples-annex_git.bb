# Copyright (c) 2019 LG Electronics, Inc.

SUMMARY = "Web app sample - annex"

require webapp-samples.inc

SAMPLE_PATH = "annex"
