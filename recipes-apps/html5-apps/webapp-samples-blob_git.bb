# Copyright (c) 2019 LG Electronics, Inc.

SUMMARY = "Web app sample - webGL blob"

require webapp-samples.inc

SAMPLE_PATH = "blob"
