# Copyright (c) 2019 LG Electronics, Inc.

SUMMARY = "Web app sample - application list"

require webapp-samples.inc

SAMPLE_PATH = "application-list"

RDEPENDS_${PN} += " \
  af-main \
"
