SUMMARY = "Google search web app"
AUTHOR = "Jose Dapena Paz"

require html5-remote.inc

APP_URL = "https://www.google.com"
