IMAGE_INSTALL_append += "\
    packagegroup-agl-demo-platform-svl-ces2020 \
    "
