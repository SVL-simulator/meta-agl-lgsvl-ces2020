AGL_APPS_remove = "\
  dashboard \
  hvac \
  mediaplayer \
  virtual/mixer \
  phone \
  poiapp \
  radio \
  settings \
  virtual/navigation \
"
